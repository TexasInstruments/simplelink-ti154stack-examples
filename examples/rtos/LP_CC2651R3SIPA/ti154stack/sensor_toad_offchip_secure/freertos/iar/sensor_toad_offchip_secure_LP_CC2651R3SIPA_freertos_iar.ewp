# IAR project sensor_toad_offchip_secure_LP_CC2651R3SIPA_freertos_iar.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  postbuild: $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/ti154stack/apps/sensor_oad_offchip/CC13X2_CC26X2R1_LAUNCHXL/sensor_oad_offchip_sec.bat $PROJ_FNAME$ $CONFIG_NAME$ $TARGET_BPATH$ $PROJ_DIR$ $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$
  group (top)
    ./: sensor_toad_offchip_secure_LP_CC2651R3SIPA_freertos_iar.ipcf SysConfig_Generated_Files.ipcf
